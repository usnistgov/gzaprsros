Commit message: back to broken

File: src/gzrcs/config/lrmate200id.urdf (robot description, URDF)
Before this commit: robot fanuc_lrmate200id, 10 links, 9 joints
Joints:
- joint fanuc_joint_5: child link_5 -> fanuc_link_5; parent link_4 -> fanuc_link_4
